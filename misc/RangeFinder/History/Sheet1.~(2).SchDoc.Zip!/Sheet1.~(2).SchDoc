# Altium schematic sheet Sheet1.~(2).SchDoc
size A

## Sub-sheets
Designator = File Name: no entries
Designator = File Name: no entries